RDEPENDS:${PN}:append = " systemd-fsnm"
