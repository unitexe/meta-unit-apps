IMAGE_INSTALL:append = " dotnet-hello-world"
